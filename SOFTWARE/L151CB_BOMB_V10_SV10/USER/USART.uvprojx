# Keil uVision project USART.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32L1XX_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\STM32L1xx_StdPeriph_Driver\inc;..\HARDWARE\DS3231;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\TM1650;..\USMART;..\HARDWARE\SHT30
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./: main.c stm32l1xx_it.c system_stm32l1xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DS3231/: DS3231.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TM1650/: tm1650.c
    ../HARDWARE/SHT30/: sht30.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32l1xx_md.s
  group FWLib
    ../STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_usart.c stm32l1xx_tim.c stm32l1xx_pwr.c
  group USAMRT
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: README.TXT
